# IAR project EQ_IDSP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\..\Libraries\EQ_IDSP_Lib\inc; ..\..\Libraries\EQ_IDSP_Lib\src; ..\..\Libraries\NANDFlash_Drv; ..\..\Libraries\W5200_Drv; User
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EQ_IDSP.bin
  ILINK.IlinkOutputFile: EQ_IDSP.out
  ILINK.IlinkIcfFile: C:\Users\Larry G\Documents\DaumCloud\ARM Project\STM32F103VCT6\Project\EQ_IDSP\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration USB Mass Storage (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group IDSP Lib/inc
    ../../Libraries/EQ_IDSP_Lib/inc/: atfc.h calendar.h clcd.h config.h diskio.h exti.h fatfs.h ff.h ffconf.h fsmc_nand.h glcd.h hw_config.h integer.h mass_mal.h memory.h nand_if.h platform_config.h rtc.h sdcard.h sdio.h usb_bot.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h usb_scsi.h wiz820io.h
    ../../Libraries/W5200_Drv/: socket.h w5200.h
  group IDSP Lib/src
    ../../Libraries/EQ_IDSP_Lib/src/: atfc.c calendar.c clcd.c config.c diskio.c exti.c fatfs.c ff.c fsmc_nand.c glcd.c hw_config.c mass_mal.c memory.c nand_if.c rtc.c scsi_data.c sdcard.c sdio.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c wiz820io.c
    ../../Libraries/W5200_Drv/: socket.c w5200.c
  group StdPeriph_Drv
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB_FS_Drv
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    User/: main.c main.h stm32f10x_it.c stm32f10x_it.h
